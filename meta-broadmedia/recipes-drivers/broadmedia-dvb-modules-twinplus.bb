KV = "3.17.8"
SRCDATE = "20151001"

require broadmedia-dvb-modules.inc

#SRC_URI = "file://twinplus-drivers-${KV}-${SRCDATE}.zip"
SRC_URI = "http://source.mynonpublic.com/broadmedia/twinplus-drivers-${KV}-${SRCDATE}.zip"

SRC_URI[md5sum] = "6661a52731fbc7a8b252144a8277c074"
SRC_URI[sha256sum] = "dc9809264d9aa79dec5f97cbdcfbad8646ea60ed8cf328e6e99a16ef557252ee"
