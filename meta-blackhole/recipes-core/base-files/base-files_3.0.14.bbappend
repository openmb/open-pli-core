PR .= "-bh1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

