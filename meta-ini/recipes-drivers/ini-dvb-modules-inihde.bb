KV = "3.12.1"
SRCDATE = "20141105"

SRC_URI[md5sum] = "914bbf931b691c6b61aeb6b07a7461da"
SRC_URI[sha256sum] = "ca507b04ab06145ddfd46d8f5e6f176f7a0cf6e26e66238803bae7286c82d20b"

SRC_URI = "http://code-ini.com/software/drivers/ini-1000-drivers-${KV}-${SRCDATE}.zip"

require ini-dvb-modules.inc