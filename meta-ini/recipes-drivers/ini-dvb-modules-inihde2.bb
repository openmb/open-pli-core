KV = "3.14.2"
SRCDATE = "20141205"

SRC_URI[md5sum] = "cc76eea3aba4fa6c866a3e795130193b"
SRC_URI[sha256sum] = "7f449d1153761071e8baaf92db2dd25c9fea719423595241b88121dbe2de0cf6"

SRC_URI = "http://code-ini.com/software/drivers/ini-422-drivers-${KV}-${SRCDATE}.zip"

require ini-dvb-modules.inc

