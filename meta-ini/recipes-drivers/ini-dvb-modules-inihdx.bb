KV = "3.6.0"
SRCDATE = "20141104"

SRC_URI[md5sum] = "f846f86b59250d9b46a79b4fb254df68"
SRC_URI[sha256sum] = "7d42d1b1a60e28aa227c13253d9edf5d081bf7f0c202a279a7a17e882f20b50a"

SRC_URI = "http://code-ini.com/software/drivers/ini-x000-drivers-${KV}-${SRCDATE}.zip"

require ini-dvb-modules.inc